Commit message: fine tuned controller and urdf

File: assets/drone_urdf/drone.urdf (robot description, URDF)
Before this commit: robot cf2, 6 links, 5 joints
Links:
- link base_link: mass 0.027 -> 0.5
