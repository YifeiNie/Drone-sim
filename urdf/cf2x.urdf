Commit message: track task converge

File: urdf/cf2x.urdf (robot description, URDF)
Before this commit: robot cf2, 6 links, 5 joints
Links:
- link base_link: mass 0.5 -> 0.027
